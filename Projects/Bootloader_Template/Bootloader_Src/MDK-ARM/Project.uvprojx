# Keil uVision project Project.uvprojx, settings and files
target STM32446E_EVAL (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F446ZE STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32446E_EVAL +hex
  AfterMake: fromelf --bin ".\..\..\prog_QSPI_flash_via_bootloader\MDK-ARM\STM32446E_EVAL\@L.axf" --output ".\Binary\@L.bin"
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F446xx,USE_STM32446E_EVAL
  c misc: --C99
  c include: ..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Inc;..\..\..\..\Drivers\BSP\STM32446E_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x20003000 size 0x4000
  memory RVCT9: RAM 0x20007000 size 0x4000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_sram.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma.c stm32f4xx_hal_rcc.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_qspi.c stm32f4xx_hal_flash.c stm32f4xx_hal_uart.c stm32f4xx_hal_flash_ex.c stm32f4xx_ll_fmc.c
  group Example/MDK-ARM
    ./: startup_stm32f446xx.s
  group Example/User
    ../Src/: stm32f4xx_hal_msp.c main.c
  group Drivers/BSP/STM32446E_EVAL
    ../../../../Drivers/BSP/STM32446E_EVAL/: stm32446e_eval.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 3.40.0
